<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>STM8</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>FWlib</name>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_clk.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_tim2.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\FWLib\source\stm8s_uart1.c</name>
    </file>
  </group>
  <group>
    <name>Main</name>
    <file>
      <name>$PROJ_DIR$\Main\main.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
  </group>
  <group>
    <name>UserSTM8</name>
    <file>
      <name>$PROJ_DIR$\UserSTM8\Source\user_delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserSTM8\Source\user_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserSTM8\Source\user_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\UserSTM8\Source\user_uart1.c</name>
    </file>
  </group>
</project>



# IAR project UART_1.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F3P STM8S103F3P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: E:\STM8s\UART\FWLib\include; E:\STM8s\UART\UserSTM8\include; E:\STM8s\UART\User\include; E:\STM8s\UART\Main
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group FWlib
    FWLib/source/: stm8s_clk.c stm8s_gpio.c stm8s_tim2.c stm8s_uart1.c
  group Main
    Main/: main.c
  group UserSTM8
    UserSTM8/Source/: user_delay.c user_gpio.c user_timer.c user_uart1.c
